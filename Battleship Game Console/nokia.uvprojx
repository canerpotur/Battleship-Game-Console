# Keil uVision project nokia.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nokia
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: nokia.s Startup.s DELAY100.s CONFIG_NOKIA.s NokiaCommands.s READ_POT1.s INIT_NOKIA.s READ_POT2.s INIT_SWITCHES.s INIT_SYSTICK_TIMER.s INIT_COUNTER.s DELAY100m.s DRAW_LOSE.s DRAW_WIN.s MINE_CHECK.s
